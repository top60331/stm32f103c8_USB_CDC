<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ly-stm32f103c8_usb.ewp</path>
  </project>
  <batchBuild />
</workspace>
